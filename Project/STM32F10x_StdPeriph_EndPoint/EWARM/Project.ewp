# IAR project Project.ewp, settings and files
configuration SPX-EP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM32100B_EVAL; xDEBUG_EN
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL; ..\Kernel; ..\SI4463; ..\UartApp; ..\BL\API; ..\BL\DataLink\MAC; ..\BL\DataLink\PhyBridge; ..\BL\Physical; ..\SimplexTransfer\EndPoint
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BL/API
    ../BL/API/: API.c
  group BL/DataLink/MAC
    ../BL/DataLink/MAC/: Frame.c PhyAddress.c
  group BL/DataLink/PhyBridge
    ../BL/DataLink/PhyBridge/: PhyBridge.h
  group BL/Physical
    ../BL/Physical/: SI4463PhyBridge.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group Kernel
    ../Kernel/: Hal_drivers.c Hal_timer.c Kernel.c Kernel_Memory.c Kernel_Timers.c
  group SI4463
    ../SI4463/: radio.c radio_comm.c radio_config.h radio_hal.c radio_mcu.c si4463.c si4463_spi.c
  group SimplexTransfer/EndPoint
    ../SimplexTransfer/EndPoint/: SimplexTransfer.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_cec.c stm32100b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_i2c_tsensor.c
  group UartApp
    ../UartApp/: uartapp.c
  group User
    ../: il_hw_init.c il_usart.c ledapp.c main.c node.c slotapp.c stm32f10x_it.c timeapp.c uart.c
